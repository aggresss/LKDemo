## exp.d/mych06/Kconfig
```kconfig
config GLOBAMEM
    tristate "globalmem test"
    default m
    ---help---
    globalmem driver example.
```
